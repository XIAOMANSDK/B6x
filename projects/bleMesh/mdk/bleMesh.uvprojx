# Keil uVision project bleMesh.uvprojx, settings and files
target bleMeshServer (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: B6x Generic
  pack: Generic.B6x.1.0.0
  cpu: CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: bleMesh +hex
  AfterMake: fromelf.exe  --bin -o "$L@L.bin" "#L"
  AfterMake: fromelf.exe  --text -a -c -o "$L@L.asm" "#L"
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: MESH_APP_MODE=0
  c misc: --c99 --thumb --gnu --bss_threshold=0 --preinclude=..\src\cfg.h --locale=english
  c include: ..\src;..\..\..\core;..\..\..\core\reg;..\..\..\drivers\api;..\..\..\modules\api;..\..\..\ble\api;..\..\..\ble\app;..\..\..\ble\prf;..\..\..\mesh\api;..\..\..\mesh\lib;..\..\..\mesh\genie;..\..\..\mesh\model\api
  asm misc: --thumb
  library: MicroLIB
  scatter file: ..\..\..\core\mdk\link_xip_mesh.sct
  link misc: --diag_suppress=L6312,L6314,L6329
  group core
    ../../../core/mdk/: startup_mesh.s
  group src
    ../src/: cfg.h main.c proc.c app_mesh_client.c app_mesh_server.c
  group drivers
    ../../../drivers/api/: drvs.h
    ../../../drivers/lib/: drvs.lib
  group modules
    ../../../modules/src/: leds.c sftmr.c
  group ble\app
    ../../../ble/app/: app.c app_actv.c app_msg.c app_gapm.c app_gapc.c app_gatt.c
  group mesh\genie
    ../../../mesh/genie/: genie_mesh.c sha256.c
  group mesh\model
    ../../../mesh/lib/: sig_model.h sig_model.lib
  group mesh\lib
    ../../../mesh/api/: mesh.h
    ../../../mesh/lib/: ble6_mesh.lib
  group debug
    ../../../modules/src/: debug.c
target bleMeshClient (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: B6x Generic
  pack: Generic.B6x.1.0.0
  cpu: CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: bleMesh +hex
  AfterMake: fromelf.exe  --bin -o "$L@L.bin" "#L"
  AfterMake: fromelf.exe  --text -a -c -o "$L@L.asm" "#L"
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: MESH_APP_MODE = 1
  c misc: as above
  c include: as above
  asm misc: --thumb
  library: MicroLIB
  scatter file: ..\..\..\core\mdk\link_xip_mesh.sct
  link misc: --diag_suppress=L6312,L6314,L6329
