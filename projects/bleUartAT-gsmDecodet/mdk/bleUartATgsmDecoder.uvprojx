# Keil uVision project bleUartATgsmDecoder.uvprojx, settings and files
target bleUartATgsmDecoder (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: B6x Generic
  pack: Generic.B6x.1.0.0
  cpu: CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: bleUartATgsmDecoder +hex
  AfterMake: fromelf.exe  --bin -o "$L@L.bin" "#L"
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --c99 --gnu --thumb --bss_threshold=0 --preinclude=..\src\cfg.h
  c include: ..\src;..\..\..\core;..\..\..\core\reg;..\..\..\drivers\api;..\..\..\modules\api;..\..\..\ble\api;..\..\..\ble\app;..\..\..\ble\prf;..\src\gsm-1.0-pl23\inc
  asm misc: --thumb
  library: MicroLIB
  scatter file: .\link_xip_ble.sct
  link misc: --diag_suppress=L6312,L6314,L6329
  group src
    ../src/: cfg.h main.c myapp.c proc.c atcmd.c gsm_audio_data.h dma_handler.c
  group core
    ../src/: startup_gsm.s
  group drivers
    ../../../drivers/api/: drvs.h
    ../../../drivers/lib/: drvs.lib
  group modules
    ../src/: uart1Rb.c
    ../../../modules/src/: leds.c sftmr.c
  group ble\app
    ../../../ble/app/: app.c app_msg.c app_gapm.c app_gapc.c app_gatt.c
    ../src/: app_actv.c
  group ble\prf
    ../../../ble/prf/: prf_diss.c
    ../src/: prf_sess.c
  group ble\lib
    ../../../ble/lib/: ble6_lite.lib
  group GSM_Decoder
    ../src/: gsm.c gsm_audio.c gsm_audio.h speaker.c speaker.h
  group GSM_Library
    ../src/gsm-1.0-pl23/src/: add.c code.c decode.c gsm_create.c gsm_decode.c gsm_destroy.c gsm_encode.c gsm_explode.c gsm_implode.c gsm_option.c long_term.c lpc.c preprocess.c rpe.c short_term.c table.c
  group debug
    ../../../modules/src/: debug.c
