# Keil uVision project bleUart2USB.uvprojx, settings and files
target ble_uart2usb (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: B6x Generic
  pack: Generic.B6x.1.0.0
  cpu: CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: ble_uart2usb +hex
  AfterMake: fromelf.exe  --bin -o "$L@L.bin" "#L"
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --c99 --thumb --gnu --bss_threshold=0 --preinclude=..\src\cfg.h --locale=english
  c include: ..\src;..\..\..\core;..\..\..\core\reg;..\..\..\drivers\api;..\..\..\modules\api;..\..\..\ble\api;..\..\..\ble\app;..\..\..\ble\prf;..\..\..\usb\api;..\..\..\usb\class\cdc
  asm misc: --thumb
  library: MicroLIB
  scatter file: ..\..\..\core\mdk\link_xip_ble.sct
  link misc: --diag_suppress=L6312,L6314,L6329,L6329
  group core
    ../../../core/mdk/: startup.s
  group src
    ../src/: cfg.h main.c myapp.c proc.c cdc_uart.c
  group drivers
    ../../../drivers/api/: drvs.h
    ../../../drivers/lib/: drvs.lib
  group modules
    ../../../modules/src/: leds.c sftmr.c uart1Rb.c
  group ble\app
    ../../../ble/app/: app.c app_actv.c app_msg.c app_gapm.c app_gapc.c
  group ble\prf
    ../../../ble/prf/: prf_diss.c prf_sess.c
  group ble\lib
    ../../../ble/lib/: ble6.lib
  group usbd
    ../../../usb/lib/: usbd.lib
    ../../../usb/api/: usbd.h
    ../../../usb/class/cdc/: usbd_cdc.c
  group debug
    ../../../modules/src/: debug.c
