# Keil uVision project bleRC_M.uvprojx, settings and files
target bleRC_M (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: B6x Generic
  pack: Generic.B6x.1.0.0
  cpu: CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: bleRC_M +hex
  AfterMake: fromelf.exe  --bin -o "$L@L.bin" "#L"
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --c99 --thumb --gnu --bss_threshold=0 --preinclude=..\src\cfg.h --locale=english
  c include: ..\src;..\..\..\..\core;..\..\..\..\core\reg;..\..\..\..\drivers\api;..\..\..\..\modules\api;..\..\..\..\ble\api;..\..\..\..\ble\app;..\..\..\..\ble\prf;..\..\..\..\usb\api;..\..\..\..\usb\class\hid;..\..\..\..\usb\class\audio
  asm misc: --thumb
  library: MicroLIB
  scatter file: ..\src\link_xip_ble.sct
  link misc: --diag_suppress=L6312,L6314,L6329
  group core
    ../../../../core/mdk/: startup.s
  group src
    ../src/: cfg.h app_user.h main.c audio_hid.c
  group modules
    ../../../../modules/src/: adpcm.c
  group drivers
    ../../../../drivers/api/: drvs.h
    ../../../../drivers/lib/: drvs.lib
  group ble\app
    ../src/: app.c app_actv.c app_msg.c app_gapc.c app_gatt.c
    ../../../../ble/app/: app_gapm.c
  group ble\lib
    ../../../../ble/lib/: ble6.lib
  group usbd
    ../../../../usb/lib/: usbd.lib
    ../../../../usb/api/: usbd.h
    ../../../../usb/class/hid/: usbd_hid.c
    ../../../../usb/class/audio/: usbd_audio.c
  group debug
    ../../../../modules/src/: debug.c
