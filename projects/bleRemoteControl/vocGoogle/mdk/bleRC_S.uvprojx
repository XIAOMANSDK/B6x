# Keil uVision project bleRC_S.uvprojx, settings and files
target bleRC_S (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: B6x Generic
  pack: Generic.B6x.1.0.0
  cpu: CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: bleRC_S +hex
  AfterMake: fromelf.exe  --bin -o "$L@L.bin" "#L"
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CACHE_USE_SRAM
  c misc: --diag_suppress=188 --c99 --gnu --thumb --bss_threshold=0 --preinclude=..\src\cfg.h --locale=english
  c include: ..\src;..\src\prf;..\src\app;..\..\..\..\core;..\..\..\..\core\reg;..\..\..\..\drivers\api;..\..\..\..\modules\api;..\..\..\..\ble\api
  asm misc: --thumb
  library: MicroLIB
  scatter file: ..\src\link_xip_blelite.sct
  link misc: --diag_suppress=L6312,L6314,L6329
  group src
    ../src/: cfg.h app_user.h main.c batt.c proc.c keys.c micphone.c ble_priv_data.c
  group core
    ../../../../core/mdk/: startup.s
  group drivers
    ../../../../drivers/api/: drvs.h
    ../../../../drivers/lib/: drvs.lib
  group modules
    ../../../../modules/src/: sftmr.c uart1Rb.c btns.c adpcm.c
    ../../../../modules/lib/: msbc.lib
  group ble\app
    ../src/app/: app.c app_actv.c app_gapm.c app_gapc.c app_msg.c
  group ble\prf
    ../src/prf/: prf_diss.c prf_bass.c prf_hids.c prf_sess.c
  group ble\lib
    ../../../../ble/lib/: ble6_lite.lib
  group debug
    ../../../../modules/src/: debug.c
