# Keil uVision project model.uvprojx, settings and files
target sigModel (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.6.0
  cpu: CPUTYPE("Cortex-M0+") CLOCK(16000000) ESEL ELITTLE
  output: sig_model (library)
  AfterMake: cmd.exe /C copy  "#L"  "$P..\lib"
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __NO_EMBEDDED_ASM
  c misc: --gnu --thumb --bss_threshold=0 --locale=english
  c include: ..\api;..\lib;..\model;..\model\api;..\..\core;..\..\ble\api;..\..\drivers\api
  link misc: --any_placement=best_fit --datacompressor=off
  group api
    ../lib/: sig_model.h
    ../api/: mm_def.h mm_itf.h
  group gens
    ../model/gen/gens/: mm_gens_oo.c mm_gens_lvl.c mm_gens_poo.c mm_gens_plvl.c mm_gens_loc.c mm_gens_dtt.c mm_gens_bat.c mm_gens_prop.c
  group genc
    ../model/gen/genc/: mm_genc_oo.c mm_genc_lvl.c mm_genc_poo.c mm_genc_plvl.c mm_genc_loc.c mm_genc_dtt.c mm_genc_bat.c mm_genc_prop.c
  group lights
    ../model/light/lights/: mm_lights_ctl.c mm_lights_hsl.c mm_lights_ln.c
  group lightc
    ../model/light/lightc/: mm_lightc_ctl.c mm_lightc_hsl.c mm_lightc_ln.c mm_lightc_xyl.c
