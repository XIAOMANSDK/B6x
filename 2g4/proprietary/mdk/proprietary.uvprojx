# Keil uVision project proprietary.uvprojx, settings and files
target proprietary (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.6.0
  cpu: CPUTYPE("Cortex-M0+") CLOCK(16000000) ESEL ELITTLE
  output: proprietary (library)
  AfterMake: cmd.exe /C copy  "#L"  "$P..\lib"
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __NO_EMBEDDED_ASM
  c misc: --gnu --thumb --bss_threshold=0 --locale=english
  c include: ..\..\..\core;..\..\..\core\reg;..\..\..\drivers\api;..\api;..\src\log;..\src\task;..\src\rf;..\src\mdm;..\src\link
  asm misc: --thumb
  link misc: --any_placement=best_fit --datacompressor=off
  group rf
    ../src/rf/: rfctrl.c rfctrl.h rfrssi.h rfrssi.c
  group api
    ../api/: link_master.h link_slave.h link_param.h link_mdm.h
  group task
    ../src/task/: task.h task.c taskx.s
  group mdm
    ../src/mdm/: mdm.c mdm.h utils.c
  group link
    ../src/link/: crc.c master.c slave.c crc.h link.h master.h slave.h circle.h circle.c median.h median.c rssi.h
  group log
    ../src/log/: log.c log.h
