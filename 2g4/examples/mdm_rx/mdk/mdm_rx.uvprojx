# Keil uVision project mdm_rx.uvprojx, settings and files
target mdm_rx (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: B6x Generic
  pack: Generic.B6x.1.0.1
  cpu: CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: mdm_rx +hex
  AfterMake: fromelf.exe  --bin -o "$L@L.bin" "#L"
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --c99 --gnu --thumb --bss_threshold=0 --preinclude=..\src\cfg.h
  c include: ..\src;..\..\..\..\core;..\..\..\..\core\reg;..\..\..\..\drivers\api;..\..\..\..\modules\api;..\..\..\proprietary\api
  asm misc: --thumb
  library: MicroLIB
  scatter file: ..\..\..\..\core\mdk\link_xip.sct
  link misc: --diag_suppress=L6312,L6314,L6329
  group core
    ../../../../core/mdk/: startup.s startup_sram.s
  group src
    ../src/: cfg.h main.c
  group drivers
    ../../../../drivers/api/: drvs.h
    ../../../../drivers/lib/: drvs.lib
  group debug
    ../../../../modules/src/: debug.c
  group link
    ../../../proprietary/api/: link_mdm.h link_param.h
    ../../../proprietary/lib/: proprietary.lib
target mdm_rx_SRAM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: B6x Generic
  pack: Generic.B6x.1.0.1
  cpu: CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: mdm_rx +hex
  AfterMake: fromelf.exe  --bin -o "$L@L.bin" "#L"
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: as above
  c include: as above
  asm misc: --thumb
  library: MicroLIB
  scatter file: ..\..\..\..\core\mdk\link_sram.sct
  link misc: --diag_suppress=L6312,L6314,L6329
