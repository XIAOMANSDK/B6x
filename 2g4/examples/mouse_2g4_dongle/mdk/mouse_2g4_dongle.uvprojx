# Keil uVision project mouse_2g4_dongle.uvprojx, settings and files
target mouse_2g4_dongle_SRAM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: B6x Generic
  pack: Generic.B6x.1.0.1
  cpu: CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: mouse_2g4_dongle +hex
  AfterMake: fromelf.exe  --bin -o "$L@L.bin" "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --c99 --gnu --thumb --bss_threshold=0 --preinclude=..\src\cfg.h
  c include: ..\src;..\..\..\..\core;..\..\..\..\core\mdk;..\..\..\..\core\reg;..\..\..\..\drivers\api;..\..\..\..\modules\api;..\..\..\proprietary\api;..\..\..\..\usb\api;..\..\..\..\usb\class\hid
  asm define: CACHE_USE_SRAM
  asm misc: --thumb
  library: MicroLIB
  scatter file: ..\..\..\..\core\mdk\link_sram.sct
  link misc: --diag_suppress=L6312,L6314,L6329
  group core
    ../../../../core/mdk/: startup.s startup_sram.s
  group src
    ../src/: cfg.h main.c masterTest.c app_user.h
  group drivers
    ../../../../drivers/api/: drvs.h
    ../../../../drivers/lib/: drvs.lib
  group debug
    ../../../../modules/src/: debug.c
  group link
    ../../../proprietary/api/: link_master.h link_param.h link_slave.h
    ../../../proprietary/lib/: proprietary.lib
  group usbd
    ../../../../usb/lib/: usbd.lib
    ../../../../usb/api/: usbd.h
    ../src/: usbd_hid.c hid_boot.c
target mouse_2g4_dongle (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: B6x Generic
  pack: Generic.B6x.1.0.1
  cpu: CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: mouse_2g4_dongle +hex
  AfterMake: fromelf.exe  --bin -o "$L@L.bin" "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: as above
  c include: as above
  asm misc: --thumb
  library: MicroLIB
  scatter file: ..\..\..\..\core\mdk\link_xip.sct
  link misc: --diag_suppress=L6312,L6314,L6329
