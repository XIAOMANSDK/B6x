# Keil uVision project gsmDecoder.uvprojx, settings and files
target gsmDecoder (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: B6x Generic
  pack: Generic.B6x.1.0.0
  cpu: CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: gsmDecoder +hex
  AfterMake: fromelf.exe  --bin -o "$L@L.bin" "#L"
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --c99 --gnu --thumb --bss_threshold=0 --preinclude=..\src\cfg.h
  c include: ..\src;..\..\..\core;..\..\..\core\mdk;..\..\..\core\reg;..\..\..\drivers\api;..\..\..\modules\api;..\..\..\ble\api;..\..\..\ble\app;..\..\..\ble\prf;..\gsm-1.0-pl23\inc
  asm misc: --thumb
  library: MicroLIB
  scatter file: .\link_xip.sct
  link misc: --diag_suppress=L6312,L6314,L6329
  group Startup
    ../src/: startup.s
  group Application
    ../src/: main.c gsm.c cfg.h gsm.h gsm_audio_data.h speakerA.c speakerB.c audio_data_500hz.c
  group GSM_Decoder
    ../gsm-1.0-pl23/src/: add.c decode.c long_term.c lpc.c rpe.c short_term.c table.c gsm_create.c gsm_destroy.c gsm_decode.c gsm_option.c gsm_print.c
  group GSM_Headers
    ../gsm-1.0-pl23/inc/: config.h private.h proto.h unproto.h
  group SDK
    ../../../modules/src/: debug.c
  group Drivers
    ../../../drivers/api/: drvs.h
    ../../../drivers/lib/: drvs.lib
