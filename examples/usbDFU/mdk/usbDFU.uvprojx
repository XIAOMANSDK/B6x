# Keil uVision project usbDFU.uvprojx, settings and files
target usbDFU (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: B6x Generic
  pack: Generic.B6x.1.0.0
  cpu: CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: usbDFU +hex
  AfterMake: fromelf.exe  --bin -o "$L@L.bin" "#L"
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --c99 --gnu --thumb --bss_threshold=0 --preinclude=..\src\cfg.h --locale=english
  c include: ..\src;..\..\..\core;..\..\..\core\reg;..\..\..\drivers\api;..\..\..\modules\api;..\..\..\usb\api;..\..\..\usb\class\hid;..\..\..\usb\class\cdc;..\..\..\usb\class\audio;..\..\..\usb\class\msc;..\..\..\usb\class\dfu
  asm misc: --thumb
  library: MicroLIB
  scatter file: ..\..\..\core\mdk\link_sram.sct
  link misc: --diag_suppress=L6312,L6314,L6329 --entry=__main
  group core
    ../src/: startup_dfu.s
  group src
    ../src/: cfg.h main.c
  group usbd
    ../../../usb/api/: usbd.h
    ../../../usb/lib/: usbd_lite.lib
    ../../../usb/class/dfu/: usbd_dfu.c
  group drivers
    ../../../drivers/api/: drvs.h
    ../../../drivers/lib/: drvs.lib
  group debug
    ../../../modules/src/: debug.c
