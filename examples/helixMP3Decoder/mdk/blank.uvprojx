# Keil uVision project blank.uvprojx, settings and files
target helixMP3Decoder (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: B6x Generic
  pack: Generic.B6x.1.0.0
  cpu: CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: helixMP3Decoder +hex
  AfterMake: fromelf.exe  --bin -o "$L@L.bin" "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: --c99 --gnu --thumb --bss_threshold=0 --preinclude=..\src\cfg.h
  c include: ..\src;..\..\..\core;..\..\..\core\mdk;..\..\..\core\reg;..\..\..\drivers\api;..\..\..\modules\api;..\..\..\ble\api;..\..\..\ble\app;..\..\..\ble\prf;..\helix\src\libhelix\real;..\helix\src\libhelix\pub;..\helix\src;..\helix
  asm misc: --thumb
  library: MicroLIB
  scatter file: .\link_xip.sct
  link misc: --diag_suppress=L6312,L6314,L6329
  group src
    ../src/: cfg.h main.c speakerA.c startup.s
    ../helix/examples/decode_custom_io/: example_decode_custom_io.c
  group debug
    ../../../modules/src/: debug.c
  group helix
    ../helix/src/libhelix/: mp3dec.c mp3tabs.c
    ../helix/src/libhelix/real/: bitstream.c buffers.c dct32.c dequant.c dqchan.c huffman.c hufftabs.c imdct.c polyphase.c scalfact.c stproc.c subband.c trigtabs.c assembly.h coder.h
    ../helix/src/libhelix/pub/: mp3common.h mp3dec.h mpadecobjfixpt.h statname.h
    ../helix/src/: helix_mp3.c helix_mp3.h
  group drv
    ../../../drivers/lib/: drvs.lib
