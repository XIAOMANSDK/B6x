# Keil uVision project usbMsc.uvprojx, settings and files
target usbMsc (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: B6x Generic
  pack: Generic.B6x.1.0.0
  cpu: CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: usbMsc +hex
  AfterMake: fromelf.exe  --bin -o "$L@L.bin" "#L"
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --c99 --gnu --thumb --bss_threshold=0 --preinclude=..\src\cfg.h --locale=english
  c include: ..\src;..\..\..\core;..\..\..\core\reg;..\..\..\drivers\api;..\..\..\modules\api;..\..\..\usb\api;..\..\..\usb\class\hid;..\..\..\usb\class\cdc;..\..\..\usb\class\audio;..\..\..\usb\class\msc
  asm misc: --thumb
  library: MicroLIB
  scatter file: ..\..\..\core\mdk\link_sram.sct
  link misc: --diag_suppress=L6312,L6314,L6329
  group core
    ../../../core/mdk/: startup_sram.s
  group src
    ../src/: cfg.h main.c msc_flash.c
  group usbd
    ../../../usb/api/: usbd.h
    ../../../usb/lib/: usbd.lib
    ../../../usb/class/msc/: usbd_msc.c
  group drivers
    ../../../drivers/api/: drvs.h
    ../../../drivers/lib/: drvs.lib
  group debug
    ../../../modules/src/: debug.c
