# Keil uVision project loader.uvprojx, settings and files
target loader (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: B6x Generic
  pack: Generic.B6x.1.0.0
  cpu: CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: loader +hex
  AfterMake: fromelf.exe  --bin -o "$L@L.bin" "#L"
  AfterMake: ..\loader_bin.bat
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __NO_EMBEDDED_ASM
  c misc: --c99 --gnu --thumb --bss_threshold=0 --preinclude=..\src\cfg.h --locale=english
  c include: ..\src;..\..\..\core;..\..\..\core\mdk;..\..\..\core\reg;..\..\..\drivers\api;..\..\..\modules\api;..\..\..\ble\api;..\..\..\ble\app;..\..\..\ble\prf
  asm misc: --thumb
  library: MicroLIB
  scatter file: .\link_ld.sct
  link misc: --diag_suppress=L6312,L6314,L6329  --entry=__main
  group src
    ../src/: cfg.h main.c
    ./: startup_ld.s
  group sct
    ./: link_ld.sct
  group drivers
    ../../../drivers/api/: drvs.h
    ../../../drivers/lib/: drvs.lib
